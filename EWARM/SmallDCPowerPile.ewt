<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>SmallDCPowerPile</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\startup_stm32f105xc.s</name>
      </file>
    </group>
    <group>
      <name>User</name>
      <group>
        <name>Core</name>
        <file>
          <name>$PROJ_DIR$\..\Core\Src\freertos.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Src\main.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Src\stm32f1xx_hal_msp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Src\stm32f1xx_hal_timebase_tim.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Src\stm32f1xx_it.c</name>
        </file>
      </group>
      <group>
        <name>Param</name>
        <file>
          <name>$PROJ_DIR$\..\Core\Param\Param_PileVar.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Param\Param_UserConfig.c</name>
        </file>
      </group>
      <group>
        <name>Thread</name>
        <group>
          <name>Thd_Charge</name>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_Charge\ChgPro_ChgBreak.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_Charge\ChgPro_ChgConfigure.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_Charge\ChgPro_ChgIdle.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_Charge\ChgPro_ChgRecognize.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_Charge\ChgPro_ChgRecognizeEx.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_Charge\ChgPro_ChgRun.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_Charge\ChgPro_ChgStart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_Charge\ChgPro_ChgStop.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_Charge\ChgPro_CommBreak.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_Charge\ChgPro_CommError.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_Charge\ChgPro_ImdCheck.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_Charge\ChgPro_ShakeHand.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_Charge\ChgPro_WaitBmsReady.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_Charge\ChgPro_WaitPillarReady.c</name>
          </file>
        </group>
        <group>
          <name>Thd_DisCharge</name>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_DisCharge\ChgPro_DisChgBreak.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_DisCharge\ChgPro_DisChgConfigure.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_DisCharge\ChgPro_DisChgIdle.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_DisCharge\ChgPro_DisChgRecognize.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_DisCharge\ChgPro_DisChgRecognizeEx.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_DisCharge\ChgPro_DisChgRun.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_DisCharge\ChgPro_DisChgStart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_DisCharge\ChgPro_DisChgStop.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_DisCharge\ChgPro_DisCommBreak.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_DisCharge\ChgPro_DisCommError.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_DisCharge\ChgPro_DisShakeHand.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_DisCharge\ChgPro_DisV2L.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_DisCharge\ChgPro_DisWaitBmsReady.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_DisCharge\ChgPro_DisWaitPillarReady.c</name>
          </file>
        </group>
        <group>
          <name>Thd_State</name>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_State\ChgPro_Sleep.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_State\ChgPro_TurnOff.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Core\Thread\Thd_State\ChgPro_TurnOn.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\Core\Thread\Thd_Charge.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Core\Thread\Thd_Monitor.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Core\Src\Global.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Drivers</name>
    <group>
      <name>ADrv</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\ADrv\ADrv_AdcVolt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\ADrv\ADrv_BmsFrame.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\ADrv\ADrv_Comm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\ADrv\ADrv_CompatibleInterface.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\ADrv\ADrv_DcModel.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\ADrv\ADrv_FDC.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\ADrv\ADrv_ImdCheck.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\ADrv\ADrv_KeyDown.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\ADrv\ADrv_LampSignals.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\ADrv\ADrv_LET.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\ADrv\ADrv_OneKeyStart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\ADrv\ADrv_PowerFailure.c</name>
      </file>
    </group>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\Core\Src\system_stm32f1xx.c</name>
      </file>
    </group>
    <group>
      <name>Drv</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\Drv\Drv_ADC.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\Drv\Drv_CAN.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\Drv\Drv_GPIO.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\Drv\Drv_I2C.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\Drv\Drv_IWDG.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\Drv\Drv_WS2812B.c</name>
      </file>
    </group>
    <group>
      <name>STM32F1xx_HAL_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_adc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_cortex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_flash_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_gpio_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rcc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_tim_ex.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Middlewares</name>
    <group>
      <name>FreeRTOS</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS\cmsis_os.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\croutine.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\event_groups.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang\heap_4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM3\port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM3\portasm.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\stream_buffer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\tasks.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\timers.c</name>
      </file>
    </group>
  </group>
</project>



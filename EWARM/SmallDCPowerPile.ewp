# IAR project SmallDCPowerPile.ewp, settings and files
configuration SmallDCPowerPile (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xB ST STM32F105xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F105xC
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\Drivers\Drv; ..\Drivers\ADrv; ..\Core\Param; ..\Core\Thread; ..\Core\Thread\Thd_Charge; ..\Core\Thread\Thd_DisCharge; ..\Core\Thread\Thd_State
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: SmallDCPowerPile.hex
  ILINK.IlinkOutputFile: SmallDCPowerPile.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f105xc.s
  group Application/User
    ../Core/Src/: Global.c
  group Application/User/Core
    ../Core/Src/: freertos.c main.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c stm32f1xx_it.c
  group Application/User/Param
    ../Core/Param/: Param_PileVar.c Param_UserConfig.c
  group Application/User/Thread
    ../Core/Thread/: Thd_Charge.c Thd_Monitor.c Thd_Mult.c
  group Application/User/Thread/Thd_Charge
    ../Core/Thread/Thd_Charge/: ChgPro_ChgBreak.c ChgPro_ChgConfigure.c ChgPro_ChgIdle.c ChgPro_ChgRecognize.c ChgPro_ChgRecognizeEx.c ChgPro_ChgRun.c ChgPro_ChgStart.c ChgPro_ChgStop.c ChgPro_CommBreak.c ChgPro_CommError.c ChgPro_ImdCheck.c ChgPro_ShakeHand.c ChgPro_WaitBmsReady.c ChgPro_WaitPillarReady.c
  group Application/User/Thread/Thd_DisCharge
    ../Core/Thread/Thd_DisCharge/: ChgPro_DisChgBreak.c ChgPro_DisChgConfigure.c ChgPro_DisChgIdle.c ChgPro_DisChgRecognize.c ChgPro_DisChgRecognizeEx.c ChgPro_DisChgRun.c ChgPro_DisChgStart.c ChgPro_DisChgStop.c ChgPro_DisCommBreak.c ChgPro_DisCommError.c ChgPro_DisShakeHand.c ChgPro_DisV2L.c ChgPro_DisWaitBmsReady.c ChgPro_DisWaitPillarReady.c
  group Application/User/Thread/Thd_State
    ../Core/Thread/Thd_State/: ChgPro_Sleep.c ChgPro_TurnOff.c ChgPro_TurnOn.c
  group Drivers/ADrv
    ../Drivers/ADrv/: ADrv_AdcVolt.c ADrv_BmsFrame.c ADrv_Comm.c ADrv_CompatibleInterface.c ADrv_DcModel.c ADrv_FDC.c ADrv_ImdCheck.c ADrv_KeyDown.c ADrv_LampSignals.c ADrv_LET.c ADrv_OneKeyStart.c ADrv_PowerFailure.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/Drv
    ../Drivers/Drv/: Drv_ADC.c Drv_CAN.c Drv_GPIO.c Drv_I2C.c Drv_IWDG.c Drv_WS2812B.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
